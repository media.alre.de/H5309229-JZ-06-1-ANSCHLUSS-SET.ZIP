Properties of the parts of a building model (IFC2X3)

# File
Description: Anschluss-Set für Differenzdruckschalter JDW/JDL, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: H5309229, Anschluss-Set für Differenzdruckschalter JDW/JDL
In: Raum
Description: Anschluss-Set mit Kanalanschlüssen aus Kunststoff, 2 x 90° Winkel, 2 Verlängerungen 90 mm, 4 selbstschneidende Schrauben, 2 m Schlauch Ø 6 mm außen für Differenzdruckschalter JDW, JDL, Druckmessumformer DF; Classification: EC010111 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: H5309229; ModelLabel: JZ-06/1; GlobalTradeItemNumber: 4050528044624; ProductURL: https://alre.de/produkt_H5309229
Pset_Specification - NominalLength: 0.09 m; NominalWidth: 0.008 m; NominalDepth: 0.008 m; NetWeight: 0.078
Pset_ALRE_ETIM_Properties - Art des Zubehörs/Ersatzteils: Messschlauchset; Zubehör: yes; ETIM-Klasse: EC010111; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-H5309229.pdf
